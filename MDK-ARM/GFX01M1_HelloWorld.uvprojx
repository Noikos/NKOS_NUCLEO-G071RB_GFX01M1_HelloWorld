# Keil uVision project GFX01M1_HelloWorld.uvprojx, settings and files
target GFX01M1_HelloWorld (ARM-ADS)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: GFX01M1_HelloWorld +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G071xx
  c include: ../DISPLAY/App;../DISPLAY/Target;../Core/Inc;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/mx25l6433f;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/ili9341
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\GFX01M1_HelloWorld.sct
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_nucleo_bus.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/User/DISPLAY/App
    ../DISPLAY/App/: app_display.c
  group Application/User/DISPLAY/Target
    ../DISPLAY/Target/: lcd_os.c lcd_io.c mem_os.c mem_io.c key_io.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/mx25l6433f/spi/: mx25l6433f.c
    ../../../../../Drivers/BSP/Components/ili9341/: ili9341.c ili9341_reg.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
