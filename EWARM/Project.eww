<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GFX01M1_HelloWorld.ewp</path>
  </project>
  <batchBuild />
</workspace>
