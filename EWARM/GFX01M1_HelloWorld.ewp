# IAR project GFX01M1_HelloWorld.ewp, settings and files
configuration GFX01M1_HelloWorld (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G071xx
  ICCARM.CCIncludePath2: ../DISPLAY/App; ../DISPLAY/Target; ../Core/Inc; ../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/mx25l6433f; ../../../../../Drivers/BSP/Components/Common; ../../../../../Drivers/BSP/Components/ili9341; ../../../../../Middlewares/NKOS/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/GFX01M1_HelloWorld.hex
  ILINK.IlinkOutputFile: GFX01M1_HelloWorld.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c stm32g0xx_nucleo_bus.c
  group Application/User/DISPLAY/App
    ../DISPLAY/App/: app_display.c noikos_loop_with_display_task.c
  group Application/User/DISPLAY/Target
    ../DISPLAY/Target/: key_io.c lcd_io.c lcd_os.c mem_io.c mem_os.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ili9341/: ili9341.c ili9341_reg.c
    ../../../../../Drivers/BSP/Components/mx25l6433f/spi/: mx25l6433f.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
  group Middlewares/NKOS
    ../../../../../Middlewares/NKOS/Src/: list.c MessageQueue.c NKOS.c
